<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bootloader\globalScaleBootloader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\globalScaleRT1024.ewp</path>
    </project>
    <batchBuild />
</workspace>
